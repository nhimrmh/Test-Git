# Keil uVision project lora.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lora
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\LoraDocument\Lora\LoraSTM32\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\LoraDocument\Lora\LoraSTM32\Drivers\CMSIS\Include;..\..\LoraDocument\Lora\LoraSTM32\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\LoraDocument\Lora\LoraSTM32\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\LoraDocument\Lora\LoraSTM32\Inc;..\..\LoraDocument\Lora\LoraSTM32\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\LoraDocument\Lora\LoraSTM32\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: startup_stm32f103xb.s
  group Drivers
    ../../LoraDocument/Lora/LoraSTM32/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usb.c
  group Src
    ../../LoraDocument/Lora/LoraSTM32/Src/: main.c mainApp.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c sx1276_7_8.c system_stm32f1xx.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Middlewares
    ../../LoraDocument/Lora/LoraSTM32/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../LoraDocument/Lora/LoraSTM32/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
